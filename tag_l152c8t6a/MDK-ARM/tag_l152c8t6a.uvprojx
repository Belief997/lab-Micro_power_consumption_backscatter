# Keil uVision project tag_l152c8t6a.uvprojx, settings and files
target tag_l152c8t6a (ARM-ADS)
  device: STM32L152C8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: tag_l152c8t6a +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xBA,USE_SX1276_RADIO
  c include: ../Core/Inc;         ../Drivers/STM32L1xx_HAL_Driver/Inc;         ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;         ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;         ../Drivers/CMSIS/Include;         ..\Core\Src\radio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l152xba.s
  group SX1278
    ../Core/Src/radio/: radio.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c ioe.c
  group Application/User/Core
    ../Core/Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_spi.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
