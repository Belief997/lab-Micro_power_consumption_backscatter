# IAR project adc_lptmr_trigger.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL03Z32xxx4 Freescale MKL03Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL03Z32VFK4; IAR; MAPS_KL03; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/utilities; ../../../../../platform/osa; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MKL03Z4; ../../../../../platform/hal; ../../../../../platform/hal/adc; ../../../../../platform/hal/cmp; ../../../../../platform/hal/cop; ../../../../../platform/hal/gpio; ../../../../../platform/hal/i2c; ../../../../../platform/hal/lptmr; ../../../../../platform/hal/mcglite; ../../../../../platform/hal/osc; ../../../../../platform/hal/pmc; ../../../../../platform/hal/port; ../../../../../platform/hal/rtc; ../../../../../platform/hal/tpm; ../../../../../platform/hal/sim; ../../../../../platform/hal/smc; ../../../../../platform/hal/spi; ../../../../../platform/hal/lpuart; ../../../../../platform/hal/wdog; ../../../../../platform/hal/llwu; ../../../../../platform/hal/rcm; ../../../../../platform/drivers; ../../../../../platform/drivers/adc; ../../../../../platform/drivers/adc/common; ../../../../../platform/drivers/cmp; ../../../../../platform/drivers/cmp/common; ../../../../../platform/drivers/cop; ../../../../../platform/drivers/cop/common; ../../../../../platform/drivers/flash; ../../../../../platform/drivers/lptmr; ../../../../../platform/drivers/lptmr/common; ../../../../../platform/drivers/tpm; ../../../../../platform/drivers/tpm/common; ../../../../../platform/drivers/gpio; ../../../../../platform/drivers/gpio/common; ../../../../../platform/drivers/i2c/i2c_master; ../../../../../platform/drivers/i2c/i2c_slave; ../../../../../platform/drivers/i2c/common; ../../../../../platform/drivers/rtc; ../../../../../platform/drivers/rtc/common; ../../../../../platform/drivers/spi; ../../../../../platform/drivers/spi/common; ../../../../../platform/drivers/spi/spi_master; ../../../../../platform/drivers/spi/spi_slave; ../../../../../platform/drivers/lpuart; ../../../../../platform/drivers/lpuart/common; ../../../../../platform/drivers/wdog; ../../../../../platform/drivers/wdog/common; ../../../../../platform/system/clock; ../../../../../platform/system/clock/MKL03Z4; ../../../../../platform/system/hwtimer; ../../../../../platform/system/interrupt; ../../../../../boards/mapskl03
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: adc_lptmr_trigger.out
  ILINK.IlinkIcfFile: ../../../../../platform/linker/iar/KL03Z4/KL03Z32xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/KL03Z4/debug/ksdk_platform_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL03Z32VFK4; IAR; MAPS_KL03; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/KL03Z4/release/ksdk_platform_lib.a
  group startup
    ../../../../../platform/startup/MKL03Z4/iar/: startup_MKL03Z4.s
    ../../../../../platform/startup/MKL03Z4/: system_MKL03Z4.c
    ../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c
    ../../../../../platform/utilities/: fsl_debug_console.h
  group source
    ../../../src/: adc_hw_trigger.c lptmr_trigger.c
    ../../../../../platform/drivers/adc/: fsl_adc_irq.c
  group board
    ../../../../../boards/mapskl03/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
