# Keil uVision project adc_lptmr_trigger.uvproj, settings and files
target adc_lptmr_trigger Debug (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: adc_lptmr_trigger.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MKL03Z32VFK4, KEIL, MAPS_KL03, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../../platform/utilities;../../../../../platform/osa;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/startup/MKL03Z4;../../../../../platform/hal;../../../../../platform/hal/adc;../../../../../platform/hal/cmp;../../../../../platform/hal/cop;../../../../../platform/hal/gpio;../../../../../platform/hal/i2c;../../../../../platform/hal/lptmr;../../../../../platform/hal/mcglite;../../../../../platform/hal/osc;../../../../../platform/hal/pmc;../../../../../platform/hal/port;../../../../../platform/hal/rtc;../../../../../platform/hal/tpm;../../../../../platform/hal/sim;../../../../../platform/hal/smc;../../../../../platform/hal/spi;../../../../../platform/hal/lpuart;../../../../../platform/hal/wdog;../../../../../platform/hal/llwu;../../../../../platform/hal/rcm;../../../../../platform/drivers;../../../../../platform/drivers/adc;../../../../../platform/drivers/adc/common;../../../../../platform/drivers/cmp;../../../../../platform/drivers/cmp/common;../../../../../platform/drivers/cop;../../../../../platform/drivers/cop/common;../../../../../platform/drivers/flash;../../../../../platform/drivers/lptmr;../../../../../platform/drivers/lptmr/common;../../../../../platform/drivers/tpm;../../../../../platform/drivers/tpm/common;../../../../../platform/drivers/gpio;../../../../../platform/drivers/gpio/common;../../../../../platform/drivers/i2c/i2c_master;../../../../../platform/drivers/i2c/i2c_slave;../../../../../platform/drivers/i2c/common;../../../../../platform/drivers/rtc;../../../../../platform/drivers/rtc/common;../../../../../platform/drivers/spi;../../../../../platform/drivers/spi/common;../../../../../platform/drivers/spi/spi_master;../../../../../platform/drivers/spi/spi_slave;../../../../../platform/drivers/lpuart;../../../../../platform/drivers/lpuart/common;../../../../../platform/drivers/wdog;../../../../../platform/drivers/wdog/common;../../../../../platform/system/clock;../../../../../platform/system/clock/MKL03Z4;../../../../../platform/system/hwtimer;../../../../../platform/system/interrupt;../../../../../boards/mapskl03
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ../../../../../platform/linker/arm/KL03Z4/KL03Z32xxx4_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/uv4/KL03Z4/debug/ksdk_platform_lib.lib 
--remove
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../../platform/utilities/: fsl_debug_console.h
  group startup
    ../../../../../platform/startup/MKL03Z4/arm/: startup_MKL03Z4.s
    ../../../../../platform/startup/MKL03Z4/: system_MKL03Z4.c
    ../../../../../platform/startup/: startup.c startup.h
  group source
    ../../../src/: adc_hw_trigger.c lptmr_trigger.c
    ../../../../../platform/drivers/adc/: fsl_adc_irq.c
  group board
    ../../../../../boards/mapskl03/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target adc_lptmr_trigger Release (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: as above
  output: adc_lptmr_trigger.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CPU_MKL03Z32VFK4, KEIL, MAPS_KL03, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/uv4/KL03Z4/release/ksdk_platform_lib.lib 
--remove
