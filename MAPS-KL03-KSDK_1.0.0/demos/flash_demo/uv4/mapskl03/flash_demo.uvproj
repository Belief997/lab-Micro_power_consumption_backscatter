# Keil uVision project flash_demo.uvproj, settings and files
target flash_demo Debug (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: flash_demo.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MKL03Z32VFK4, KEIL, MAPS_KL03, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../platform/utilities;../../../../platform/osa;../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MKL03Z4;../../../../platform/hal;../../../../platform/hal/adc;../../../../platform/hal/cmp;../../../../platform/hal/cop;../../../../platform/hal/gpio;../../../../platform/hal/i2c;../../../../platform/hal/lptmr;../../../../platform/hal/mcglite;../../../../platform/hal/osc;../../../../platform/hal/pmc;../../../../platform/hal/port;../../../../platform/hal/rtc;../../../../platform/hal/tpm;../../../../platform/hal/sim;../../../../platform/hal/smc;../../../../platform/hal/spi;../../../../platform/hal/lpuart;../../../../platform/hal/wdog;../../../../platform/hal/llwu;../../../../platform/hal/rcm;../../../../platform/drivers;../../../../platform/drivers/adc;../../../../platform/drivers/adc/common;../../../../platform/drivers/cmp;../../../../platform/drivers/cmp/common;../../../../platform/drivers/cop;../../../../platform/drivers/cop/common;../../../../platform/drivers/flash;../../../../platform/drivers/lptmr;../../../../platform/drivers/lptmr/common;../../../../platform/drivers/tpm;../../../../platform/drivers/tpm/common;../../../../platform/drivers/gpio;../../../../platform/drivers/gpio/common;../../../../platform/drivers/i2c/i2c_master;../../../../platform/drivers/i2c/i2c_slave;../../../../platform/drivers/i2c/common;../../../../platform/drivers/rtc;../../../../platform/drivers/rtc/common;../../../../platform/drivers/spi;../../../../platform/drivers/spi/common;../../../../platform/drivers/spi/spi_master;../../../../platform/drivers/spi/spi_slave;../../../../platform/drivers/lpuart;../../../../platform/drivers/lpuart/common;../../../../platform/drivers/wdog;../../../../platform/drivers/wdog/common;../../../../platform/system/clock;../../../../platform/system/clock/MKL03Z4;../../../../platform/system/hwtimer;../../../../platform/system/interrupt;../../../../platform/drivers/flash/C90TFS/drvsrc/include;../../src;../../../../boards/mapskl03
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ../../../../platform/linker/arm/KL03Z4/KL03Z32xxx4_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/uv4/KL03Z4/debug/ksdk_platform_lib.lib 
--remove
  group utilities
    ../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../platform/utilities/: fsl_debug_console.h
  group startup
    ../../../../platform/startup/MKL03Z4/arm/: startup_MKL03Z4.s
    ../../../../platform/startup/MKL03Z4/: system_MKL03Z4.c
    ../../../../platform/startup/: startup.c startup.h
  group source
    ../../src/: flash_demo.c flash_swap.c user_cfg.h
  group flash
    ../../../../platform/drivers/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../platform/drivers/flash/C90TFS/drvsrc/include/: FTFx_CX_(128_64_32)K_32K_2K_1K_1K.h FTFx_CX_256K_32K_2K_1K_1K.h FTFx_DX_(64_48_32_16)K_0K_0K_1K_0K.h FTFx_DX_(256_128_96_64)K_32K_2K_2K_1K.h FTFx_KX_(128_64_32)K_0K_0K_2K_0K.h FTFx_KX_(128_64_32)K_0K_2K_1K_0K.h FTFx_KX_(128_64_32)K_32K_2K_1K_1K.h FTFx_KX_(256_128)K_64K_4K_2K_2K.h FTFx_KX_(256_128_64)K_32K_2K_2K_1K.h FTFx_KX_(256_128_64_32_16_8)K_0K_0K_1K_0K.h FTFx_KX_(512_256)K_0K_4K_2K_0K.h FTFx_KX_128K_128K_4K_2K_2K.h FTFx_KX_256K_256K_4K_2K_2K.h FTFx_KX_512K_128K_4K_4K_4K.h FTFx_KX_512K_512K_16K_4K_4K.h FTFx_KX_1024K_0K_(16_4)K_4K_0K.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group board
    ../../../../boards/mapskl03/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target flash_demo Release (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: as above
  output: flash_demo.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, CPU_MKL03Z32VFK4, KEIL, MAPS_KL03, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ../../../../platform/linker/arm/KL03Z4/KL03Z32xxx4_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/uv4/KL03Z4/release/ksdk_platform_lib.lib 
--remove
