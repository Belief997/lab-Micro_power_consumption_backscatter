# IAR project ksdk_platform_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL03Z32xxx4 Freescale MKL03Z32xxx4
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL03Z32VFK4; IAR; MAPS_KL03; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/osa; ../../../../platform/CMSIS/Include; ../../../../platform/CMSIS/Include/device; ../../../../platform/startup/MKL03Z4; ../../../../platform/utilities; ../../../../platform/hal/adc; ../../../../platform/hal/cmp; ../../../../platform/hal/cop; ../../../../platform/hal/gpio; ../../../../platform/hal/i2c; ../../../../platform/hal/lptmr; ../../../../platform/hal/llwu; ../../../../platform/hal/mcglite; ../../../../platform/hal/osc; ../../../../platform/hal/pmc; ../../../../platform/hal/port; ../../../../platform/hal/rtc; ../../../../platform/hal/sim; ../../../../platform/hal/smc; ../../../../platform/hal/rcm; ../../../../platform/hal/spi; ../../../../platform/hal/tpm; ../../../../platform/hal/lpuart; ../../../../platform/drivers; ../../../../platform/drivers/adc; ../../../../platform/drivers/adc/common; ../../../../platform/drivers/cmp; ../../../../platform/drivers/cmp/common; ../../../../platform/drivers/cop; ../../../../platform/drivers/cop/common; ../../../../platform/drivers/gpio; ../../../../platform/drivers/gpio/common; ../../../../platform/drivers/i2c/i2c_master; ../../../../platform/drivers/i2c/i2c_slave; ../../../../platform/drivers/i2c/common; ../../../../platform/drivers/lptmr; ../../../../platform/drivers/lptmr/common; ../../../../platform/drivers/lpuart; ../../../../platform/drivers/lpuart/common; ../../../../platform/drivers/rtc; ../../../../platform/drivers/rtc/common; ../../../../platform/drivers/spi/spi_master; ../../../../platform/drivers/spi/spi_slave; ../../../../platform/drivers/spi/common; ../../../../platform/drivers/tpm; ../../../../platform/drivers/tpm/common; ../../../../platform/system/clock; ../../../../platform/system/clock/MKL03Z4; ../../../../platform/system/hwtimer; ../../../../platform/system/interrupt; ../../../../platform/system/power
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL03Z32VFK4; IAR; MAPS_KL03; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group osa
    ../../../../platform/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h
    ../../../../platform/osa/src/: fsl_os_abstraction_bm.c
  group platform/adc/common
    ../../../../platform/drivers/adc/common/: fsl_adc_common.c fsl_adc_common.h
  group platform/adc/drivers
    ../../../../platform/drivers/adc/src/: fsl_adc_driver.c
    ../../../../platform/drivers/adc/: fsl_adc_driver.h
  group platform/adc/hal
    ../../../../platform/hal/adc/: fsl_adc_features.h fsl_adc_hal.c fsl_adc_hal.h
  group platform/clock/system
    ../../../../platform/system/clock/MKL03Z4/: fsl_clock_KL03Z4.c fsl_clock_KL03Z4.h
    ../../../../platform/system/clock/: fsl_clock_manager.c fsl_clock_manager.h
  group platform/cmp/drivers
    ../../../../platform/drivers/cmp/common/: fsl_cmp_common.c fsl_cmp_common.h
    ../../../../platform/drivers/cmp/src/: fsl_cmp_driver.c
    ../../../../platform/drivers/cmp/: fsl_cmp_driver.h
  group platform/cmp/hal
    ../../../../platform/hal/cmp/: fsl_cmp_features.h fsl_cmp_hal.c fsl_cmp_hal.h
  group platform/cop/common
    ../../../../platform/drivers/cop/common/: fsl_cop_common.c fsl_cop_common.h
  group platform/cop/drivers
    ../../../../platform/drivers/cop/src/: fsl_cop_driver.c
    ../../../../platform/drivers/cop/: fsl_cop_driver.h
  group platform/cop/hal
    ../../../../platform/hal/cop/: fsl_cop_features.h fsl_cop_hal.c fsl_cop_hal.h
  group platform/gpio/common
    ../../../../platform/drivers/gpio/common/: fsl_gpio_common.c fsl_gpio_common.h
  group platform/gpio/drivers
    ../../../../platform/drivers/gpio/src/: fsl_gpio_driver.c
    ../../../../platform/drivers/gpio/: fsl_gpio_driver.h
  group platform/gpio/hal
    ../../../../platform/hal/gpio/: fsl_gpio_features.h fsl_gpio_hal.c fsl_gpio_hal.h
  group platform/hwtimer/system
    ../../../../platform/system/hwtimer/src/: fsl_hwtimer.c fsl_hwtimer_systick.c
    ../../../../platform/system/hwtimer/: fsl_hwtimer.h fsl_hwtimer_systick.h
  group platform/i2c/drivers/common
    ../../../../platform/drivers/i2c/common/: fsl_i2c_common.c fsl_i2c_common.h fsl_i2c_shared_function.c fsl_i2c_shared_function.h
  group platform/i2c/drivers/master
    ../../../../platform/drivers/i2c/i2c_master/src/: fsl_i2c_master_driver.c
    ../../../../platform/drivers/i2c/i2c_master/: fsl_i2c_master_driver.h
  group platform/i2c/drivers/slave
    ../../../../platform/drivers/i2c/i2c_slave/src/: fsl_i2c_slave_driver.c
    ../../../../platform/drivers/i2c/i2c_slave/: fsl_i2c_slave_driver.h
  group platform/i2c/hal
    ../../../../platform/hal/i2c/: fsl_i2c_features.h fsl_i2c_hal.c fsl_i2c_hal.h
  group platform/interrupt/system
    ../../../../platform/system/interrupt/src/: fsl_interrupt_manager.c
    ../../../../platform/system/interrupt/: fsl_interrupt_manager.h
  group platform/llwu/hal
    ../../../../platform/hal/llwu/: fsl_llwu_features.h fsl_llwu_hal.c fsl_llwu_hal.h
  group platform/lptmr/common
    ../../../../platform/drivers/lptmr/common/: fsl_lptmr_common.c fsl_lptmr_common.h
  group platform/lptmr/drivers
    ../../../../platform/drivers/lptmr/src/: fsl_lptmr_driver.c
    ../../../../platform/drivers/lptmr/: fsl_lptmr_driver.h
  group platform/lptmr/hal
    ../../../../platform/hal/lptmr/: fsl_lptmr_features.h fsl_lptmr_hal.c fsl_lptmr_hal.h
  group platform/lpuart/common
    ../../../../platform/drivers/lpuart/common/: fsl_lpuart_common.c fsl_lpuart_common.h
  group platform/lpuart/drivers
    ../../../../platform/drivers/lpuart/src/: fsl_lpuart_driver.c
    ../../../../platform/drivers/lpuart/: fsl_lpuart_driver.h
  group platform/lpuart/hal
    ../../../../platform/hal/lpuart/: fsl_lpuart_features.h fsl_lpuart_hal.c fsl_lpuart_hal.h
  group platform/mcglite/hal
    ../../../../platform/hal/mcglite/: fsl_mcglite_hal.c fsl_mcglite_hal.h fsl_mcglite_hal_modes.c fsl_mcglite_hal_modes.h
  group platform/osc/hal
    ../../../../platform/hal/osc/: fsl_osc_features.h fsl_osc_hal.c fsl_osc_hal.h
  group platform/pmc/hal
    ../../../../platform/hal/pmc/: fsl_pmc_features.h fsl_pmc_hal.c fsl_pmc_hal.h
  group platform/port/hal
    ../../../../platform/hal/port/: fsl_port_features.h fsl_port_hal.c fsl_port_hal.h
  group platform/power/system
    ../../../../platform/system/power/src/: fsl_power_manager.c
    ../../../../platform/system/power/: fsl_power_manager.h
  group platform/rcm/hal
    ../../../../platform/hal/rcm/: fsl_rcm_features.h fsl_rcm_hal.c fsl_rcm_hal.h
  group platform/rtc/drivers
    ../../../../platform/drivers/rtc/common/: fsl_rtc_common.c fsl_rtc_common.h
    ../../../../platform/drivers/rtc/src/: fsl_rtc_driver.c
    ../../../../platform/drivers/rtc/: fsl_rtc_driver.h
  group platform/rtc/hal
    ../../../../platform/hal/rtc/: fsl_rtc_features.h fsl_rtc_hal.c fsl_rtc_hal.h
  group platform/sim/hal
    ../../../../platform/hal/sim/: fsl_sim_hal.c fsl_sim_hal.h
  group platform/sim/system
    ../../../../platform/hal/sim/MKL03Z4/: fsl_sim_hal_KL03Z4.c fsl_sim_hal_KL03Z4.h
  group platform/smc/hal
    ../../../../platform/hal/smc/: fsl_smc_features.h fsl_smc_hal.c fsl_smc_hal.h
  group platform/spi
    ../../../../platform/drivers/spi/spi_master/: fsl_spi_master_driver.h
    ../../../../platform/drivers/spi/spi_slave/: fsl_spi_slave_driver.h
  group platform/spi/drivers
    ../../../../platform/drivers/spi/common/: fsl_spi_common.c fsl_spi_common.h fsl_spi_shared_function.c fsl_spi_shared_function.h
    ../../../../platform/drivers/spi/spi_master/src/: fsl_spi_master_driver.c
    ../../../../platform/drivers/spi/spi_slave/src/: fsl_spi_slave_driver.c
  group platform/spi/hal
    ../../../../platform/hal/spi/: fsl_spi_features.h fsl_spi_hal.c fsl_spi_hal.h
  group platform/tpm/drivers
    ../../../../platform/drivers/tpm/src/: fsl_tpm_driver.c
    ../../../../platform/drivers/tpm/: fsl_tpm_driver.h
  group platform/tpm/drivers/common
    ../../../../platform/drivers/tpm/common/: fsl_tpm_common.c fsl_tpm_common.h
  group platform/tpm/hal
    ../../../../platform/hal/tpm/: fsl_tpm_features.h fsl_tpm_hal.c fsl_tpm_hal.h
