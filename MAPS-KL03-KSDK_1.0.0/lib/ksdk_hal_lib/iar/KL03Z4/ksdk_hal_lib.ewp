# IAR project ksdk_hal_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL03Z32xxx4 Freescale MKL03Z32xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL03Z32VFK4; IAR; MAPS_KL03; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/CMSIS/Include; ../../../../platform/CMSIS/Include/device; ../../../../platform/startup/MKL03Z4; ../../../../platform/utilities; ../../../../platform/hal/sim
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL03Z32VFK4; IAR; MAPS_KL03; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group platform/hal/adc
    ../../../../platform/hal/adc/: fsl_adc_features.h fsl_adc_hal.c fsl_adc_hal.h
  group platform/hal/cmp
    ../../../../platform/hal/cmp/: fsl_cmp_features.h fsl_cmp_hal.c fsl_cmp_hal.h
  group platform/hal/cop
    ../../../../platform/hal/cop/: fsl_cop_features.h fsl_cop_hal.c fsl_cop_hal.h
  group platform/hal/gpio
    ../../../../platform/hal/gpio/: fsl_gpio_features.h fsl_gpio_hal.c fsl_gpio_hal.h
  group platform/hal/i2c
    ../../../../platform/hal/i2c/: fsl_i2c_features.h fsl_i2c_hal.c fsl_i2c_hal.h
  group platform/hal/llwu
    ../../../../platform/hal/llwu/: fsl_llwu_features.h fsl_llwu_hal.c fsl_llwu_hal.h
  group platform/hal/lptmr
    ../../../../platform/hal/lptmr/: fsl_lptmr_features.h fsl_lptmr_hal.c fsl_lptmr_hal.h
  group platform/hal/mcglite
    ../../../../platform/hal/mcglite/: fsl_mcglite_features.h fsl_mcglite_hal.c fsl_mcglite_hal.h fsl_mcglite_hal_modes.c fsl_mcglite_hal_modes.h
  group platform/hal/osc
    ../../../../platform/hal/osc/: fsl_osc_features.h fsl_osc_hal.c fsl_osc_hal.h
  group platform/hal/port
    ../../../../platform/hal/port/: fsl_port_features.h fsl_port_hal.c fsl_port_hal.h
  group platform/hal/rcm
    ../../../../platform/hal/rcm/: fsl_rcm_features.h fsl_rcm_hal.c fsl_rcm_hal.h
  group platform/hal/rtc
    ../../../../platform/hal/rtc/: fsl_rtc_features.h fsl_rtc_hal.c fsl_rtc_hal.h fsl_rtc_hal_access_control.h fsl_rtc_hal_monotonic.h
  group platform/hal/sim
    ../../../../platform/hal/sim/: fsl_sim_features.h fsl_sim_hal.c fsl_sim_hal.h
  group platform/hal/sim/system
    ../../../../platform/hal/sim/MKL03Z4/: fsl_sim_hal_KL03Z4.c fsl_sim_hal_KL03Z4.h
  group platform/hal/smc
    ../../../../platform/hal/smc/: fsl_smc_features.h fsl_smc_hal.c fsl_smc_hal.h
  group platform/hal/spi
    ../../../../platform/hal/spi/: fsl_spi_features.h fsl_spi_hal.c fsl_spi_hal.h
  group platform/hal/tpm
    ../../../../platform/hal/tpm/: fsl_tpm_features.h fsl_tpm_hal.h fsl_tpm_hal.c
  group platform/hal/lpuart
    ../../../../platform/hal/lpuart/: fsl_lpuart_features.h fsl_lpuart_hal.h fsl_lpuart_hal.c
  group platform/hal/pmc
    ../../../../platform/hal/pmc/: fsl_pmc_features.h fsl_pmc_hal.c fsl_pmc_hal.h
