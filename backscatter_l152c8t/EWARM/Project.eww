<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\backscatter_l152c8t.ewp</path>
  </project>
  <batchBuild />
</workspace>
